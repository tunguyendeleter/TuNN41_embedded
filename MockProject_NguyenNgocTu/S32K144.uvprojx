# Keil uVision project S32K144.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: S32K144HAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: C:\Users\tungu\AppData\Local\Arm\Packs\Keil\S32_SDK_DFP\1.5.0\platform\devices\S32K144\linker\armc\S32K144_64_flash.sct
  group Source Group 1
    ./: S32K144xx.h port.h port.c nvic.h nvic.c systick.c systick.h lpuart.c lpuart.h clock.c clock.h lpit.c lpit.h adc.h adc.c lpspi.c lpspi.h MockProject.c config.h sevenseg.c sevenseg.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0
